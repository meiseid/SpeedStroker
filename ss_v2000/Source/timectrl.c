#include "timectrl.h"
#include "appdata.h"

extern HWND g_hWnd;

static UINT g_uCurTimer=0; 

#define STROKE_TIMEOUT_DEFAULT	7000
#define STATUS_TIMEOUT_DEFAULT	500
#define FADE_TIMEOUT_DEFAULT		100

VOID StartTimer( UINT uTimerID )
{
	UINT uTimeout;
	
	switch( uTimerID ){
		case ST_STROKE:
			uTimeout = STROKE_TIMEOUT_DEFAULT;	
		break;
		
		case ST_STATUS:
			uTimeout = STATUS_TIMEOUT_DEFAULT;
		break;
		
		case ST_MODEB:
		case ST_MODED:
		case ST_MODEA:
		case ST_MODEC:
		case ST_MODEE:
		case ST_MODEF:
		case ST_MODEG:
			uTimeout = FADE_TIMEOUT_DEFAULT;
		break;
	}

	StartTimerEx( uTimerID,uTimeout );	
}

VOID StartTimerEx( UINT uTimerID,UINT uTimeout )
{	
	EndTimer();
	
	//作成できない場合はシステムエラー終了
	if( !SetTimer( g_hWnd,uTimerID,uTimeout,NULL )){
		ErrorExit( ERR_SYSTEM );
		return;
	}
	
	g_uCurTimer = uTimerID;
}

VOID EndTimer( VOID )
{
	if( g_uCurTimer )
		KillTimer( g_hWnd,g_uCurTimer );

	g_uCurTimer=0;
}







