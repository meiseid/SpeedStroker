#include "drawctrl.h"
#include "modea.h"
#include "timectrl.h"
#include "appdata.h"
#include "fade.h"

extern HWND g_hWnd;

static HFONT g_hFontOld; /* Work */

static BOOL	g_bIsWaiting = FALSE;

static TEXTFADE g_tfYear;	//CopyRight
static TEXTFADE g_tfName;	//My Name

VOID StartModeA( BOOL bErase )
{
	g_tfYear.rgbOrg.rgbRed = 0x00; 
	g_tfYear.rgbOrg.rgbGreen = 0xFF;
	g_tfYear.rgbOrg.rgbBlue = 0x00;
	
	g_tfName.rgbOrg.rgbRed = 0xFF; 
	g_tfName.rgbOrg.rgbGreen = 0xFF;
	g_tfName.rgbOrg.rgbBlue = 0xFF;

	g_bIsWaiting = FALSE;

	BeginTextFade( &g_tfYear );
	BeginTextFade( &g_tfName );

	SwitchScreen( SS_MODEA, bErase/* AllWays FALSE!*/ );	

}

BOOL ProcessModeA( VOID )
{
	FADESTATUS st;

	if( g_bIsWaiting ){
		g_bIsWaiting = FALSE;
		StartTimer( ST_MODEA );
		return TRUE;
	}

		st = FadeTextFade( &g_tfYear );
		st = FadeTextFade( &g_tfName );
		InvalidateRect( g_hWnd,GetRectangle( GR_MODEA_YEAR ),FALSE );
		InvalidateRect( g_hWnd,GetRectangle( GR_MODEA_NAME ),FALSE );
		if( st==FADE_INEND ){ //Let's Delay
			g_bIsWaiting = TRUE;
			StartTimerEx( ST_MODEA,3000 );
			return TRUE;
		}
		else if( st == FADE_OUTEND ){
			EndTimer();
			return FALSE;
		}
		
	return TRUE;
}

VOID DrawModeA( HDC hDC )
{
	 SELECTFONT( GetFont(GF_MODEA_YEAR) );
	 COLORTEXT( g_tfYear.rgbNow.rgbRed,g_tfYear.rgbNow.rgbGreen,g_tfYear.rgbNow.rgbBlue );
     	 DRAWTEXTCENTER( GetString( GS_MODEA_YEAR ),GetRectangle(GR_MODEA_YEAR) );
	 RESTOREFONT();
	 
	 SELECTFONT( GetFont(GF_MODEA_NAME) );
	 COLORTEXT( g_tfName.rgbNow.rgbRed,g_tfName.rgbNow.rgbGreen,g_tfName.rgbNow.rgbBlue );
     	 DRAWTEXTCENTER( GetString( GS_MODEA_NAME ),GetRectangle(GR_MODEA_NAME) );
	 RESTOREFONT();

}













